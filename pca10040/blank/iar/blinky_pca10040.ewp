# IAR project blinky_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD_PCA10040; BSP_DEFINES_ONLY; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74
  ICCARM.IExtraOptions: --diag_suppress Pe111
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\src\components; ..\..\..\src\components\boards; ..\..\..\src\components\drivers_nrf\nrf_soc_nosd; ..\..\..\src\components\libraries\atomic; ..\..\..\src\components\libraries\balloc; ..\..\..\src\components\libraries\bsp; ..\..\..\src\components\libraries\delay; ..\..\..\src\components\libraries\experimental_section_vars; ..\..\..\src\components\libraries\log; ..\..\..\src\components\libraries\log\src; ..\..\..\src\components\libraries\memobj; ..\..\..\src\components\libraries\ringbuf; ..\..\..\src\components\libraries\strerror; ..\..\..\src\components\libraries\util; ..\..\..\src\components\toolchain\cmsis\include; ..\..\..; ..\..\..\src\external\fprintf; ..\..\..\src\integration\nrfx; ..\..\..\src\modules\nrfx; ..\..\..\src\modules\nrfx\hal; $PROJ_DIR$.\..\..\..\src\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  OBJCOPY.OOCOutputFile: blinky_pca10040.hex
  ILINK.IlinkOutputFile: blinky_pca10040.out
  ILINK.IlinkIcfFile: blinky_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../src/: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../src/components/boards/: boards.c
  group None
    ../../../src/modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
  group nRF_Drivers
    ../../../src/modules/nrfx/soc/: nrfx_atomic.c
  group nRF_Libraries
    ../../../src/components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../src/components/libraries/atomic/: nrf_atomic.c
    ../../../src/components/libraries/balloc/: nrf_balloc.c
    ../../../src/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../src/components/libraries/memobj/: nrf_memobj.c
    ../../../src/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../src/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../src/components/libraries/log/src/: nrf_log_frontend.c nrf_log_str_formatter.c
